# Keil uVision project QuadrotorAircraft.uvprojx, settings and files
target QuadrotorAircraft (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: QuadrotorAircraft +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Attitude;..\BSP;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../BSP/: MPU6050.c Motor.c Motor.h MPU6050.h MyIIC.c MyIIC.h MySerial.c MySerial.h Receiver.c Receiver.h UpdateMotorState.c UpdateMotorState.h
  group Attitude
    ../Attitude/: Anonymity.c Anonymity.h AttitudeSolver.c AttitudeSolver.h GaussNewton.c GaussNewton.h MadgWick.c MadgWick.h MyMadgWick.c MyMadgWick.h PID.c PID.h AttitudePIDController.c AttitudePIDController.h
  group Source
    ../Source/: app.c switch.c tBitMap.c tConfig.h tCpu.c tEvent.c tEvent.h tFlagGroup.c tFlagGroup.h tHooks.c tHooks.h tinyOS.h tLib.h tList.c tMbox.c tMbox.h tMemBlock.c tMemBlock.h tMutex.c tMutex.h tSem.c tSem.h tTask.c tTask.h tTime.c tTimer.c tTimer.h tinyOS.c
software components: CMSIS:CORE 4.3.0
