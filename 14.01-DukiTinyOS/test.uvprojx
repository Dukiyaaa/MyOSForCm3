# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c
    ./Source/: tinyOS.h switch.c tLib.h tBitMap.c tConfig.h tList.c tTask.c tTime.c tCpu.c app.c tEvent.h tEvent.c tTask.h tSem.h tSem.c tMbox.h tMbox.c tMemBlock.c tMemBlock.h tFlagGroup.c tFlagGroup.h tMutex.c tMutex.h tTimer.c tTimer.h tHooks.c tHooks.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
